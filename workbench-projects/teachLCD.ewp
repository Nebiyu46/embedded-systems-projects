# IAR project teachLCD.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: teachLCD.hex
  ILINK.IlinkOutputFile: teachLCD.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
